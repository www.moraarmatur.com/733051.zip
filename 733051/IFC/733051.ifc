Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X_PLATFORM
File name: Default Project
Time: 2009-08-25T18:17:53
Written by: Revit Architecture 2009 - 1.0
Made in: 20080321_1900

# IfcSite, Default
RefLatitude: 42, 12, 46, 800000; RefLongitude: -71, -1, -58, -800000; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
Elevation: 0 mm
PSet_Revit_Identity Data - Name: Level 1
PSet_Revit_Constraints - Elevation: 0 mm
PSet_Revit_Type_Graphics - Line Weight: 1; Color: 0; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
PSet_Revit_Type_Constraints - Elevation Base: 0
PSet_Revit_Type_Dimensions - Automatic Room Computation Height: no; Computation Height: 1200 mm

# IfcBuildingElementProxy: Mora MMIX 733051, 733051:Mora MMIX 733051:Mora MMIX 733051:126452
In: Level 1
PSet_Revit_Dimensions - Basin Height: 850 mm
PSet_Revit_Constraints - Host: Level : Level 1; Offset: 0 mm; Moves With Nearby Elements: no
PSet_Revit_Identity Data - Mark: 30
PSet_Revit_Type_Identity Data - VVS: -; URL: www.moraarmatur.com; RSK: 834 45 08; NRF: 429 00 48; Model: 733051; Manufacturer: Mora Armatur; LVI: -; Family: Mora MMIX; EAN: 7391887220975; Description: Mora MMIX B5 Basin Mixer w pop-up waste, chrome
